# Keil uVision project SPIFIdriver.uvproj, settings and files
target Cortex-M-LPC18xx (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SPIFI_LPC18xx-43xx_800
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=3
  c define: CORE_M3 EUROBIRD USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  c include: ..\SPIFIdriver
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group SPIFI Lib
    C:/Keil/ARM/Flash/SPIFIdriver/: spifi_drv_PI.lib
